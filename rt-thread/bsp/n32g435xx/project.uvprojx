# Keil uVision project project.uvprojx, settings and files
target rtthread-nano-n32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G435CB Nationstech
  pack: Nationstech.N32G43x_DFP.0.1.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G43X, USE_STDPERIPH_DRIVER
  c include: ..\..\include;..\..\include\libc;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\finsh;..\..\components\device;..\..\components\drivers\inc;.\;.\applications;.\drivers;.\Libraries\CMSIS\core;.\Libraries\CMSIS\device;.\Libraries\n32g43x_std_periph_driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\n32_rom.sct
  group applications
    ./applications/: main.c
  group drivers
    ./drivers/: board.c drv_adc.c drv_common.c drv_gpio.c drv_usart.c finsh_port.c
  group lib
    ./Libraries/CMSIS/device/startup/: startup_n32g43x.s
    ./Libraries/CMSIS/device/: system_n32g43x.c
    ./Libraries/n32g43x_std_periph_driver/src/: misc.c n32g43x_adc.c n32g43x_can.c n32g43x_comp.c n32g43x_crc.c n32g43x_dac.c n32g43x_dbg.c n32g43x_dma.c n32g43x_exti.c n32g43x_flash.c n32g43x_gpio.c n32g43x_i2c.c n32g43x_iwdg.c n32g43x_lptim.c n32g43x_lpuart.c n32g43x_opamp.c n32g43x_pwr.c n32g43x_rcc.c n32g43x_rtc.c n32g43x_spi.c n32g43x_tim.c n32g43x_tsc.c n32g43x_usart.c n32g43x_wwdg.c
  group rtthread-nano
    ../../src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group components
    ../../components/finsh/: cmd.c msh.c shell.c
    ../../components/device/: device.c
    ../../components/drivers/src/: adc.c i2c_core.c i2c_dev.c i2c-bit-ops.c pin.c serial.c completion.c dataqueue.c waitqueue.c
  group libcpu
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
